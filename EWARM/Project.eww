<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F7_CDC.ewp</path>
  </project>
  <batchBuild />
</workspace>
